# Keil uVision project web_uip.uvprojx, settings and files
target ptp_daemon (ARM-ADS)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.9
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: AT32F437ZMT7,USE_STDPERIPH_DRIVER,AT_START_F437_V1
  c include: ..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\at32f435_437_board;..\..\..\..\..\middlewares\3rd_party\uip\inc;..\..\uip_app_src\webserver\inc;..\..\uip_app_src\Eth_app\dhcpc;..\..\dm9051_elwip;..\..\uip_arch_src\UNIX;..\..\uip_app_src\Eth_app\resolv;..\..\..\..\..\middlewares\3rd_party\uip\port\at32f415_dm9051;..\..\..\dm9051_u2510_r_9_1;..\..\uip_conf_inc
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group user
    ../src/: main.c netconf.c at32f435_437_clock.c at32f435_437_int.c
  group bsp
    ../../../../at32f435_437_board/: at32f435_437_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f435_437_crm.c at32f435_437_exint.c at32f435_437_gpio.c at32f435_437_misc.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_spi.c at32f435_437_scfg.c at32f435_437_dma.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f435_437.c
  group uip_arch
    ../../uip_arch_src/UNIX/: clock-arch.c main_unix.c
    ../../uip_app_src/: app_call.c uip-conf.c
    ../../uip_app_src/webserver/src/DM/: httpd.c httpd-fs.c httpd-cgi-test1.c http-strings.c
    ../../../../../middlewares/3rd_party/uip/port/at32f415_dm9051/: ethernetif.c
    ../../../dm9051_u2510_if/common/: platforminfo_uip_v0.c
  group uip
    ../../../../../middlewares/3rd_party/uip/src/: uip.c uip_arp.c timer.c psock - EditA.c
    ../../uip_app_src/Eth_app/debug_app/: debug_app.c
    ../../uip_app_src/Eth_app/resolv/: resolv.c
  group new
    ../../../dm9051_u2510_r_9_1/core/: dm9051.c
    ../../../dm9051_u2510_r_9_1/hal/SPI1/: at32f437_spi1.c
    ../src/: main_env.c
