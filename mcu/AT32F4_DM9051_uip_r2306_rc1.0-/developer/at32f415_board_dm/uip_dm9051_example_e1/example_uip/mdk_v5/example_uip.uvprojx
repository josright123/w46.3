# Keil uVision project example_uip.uvprojx, settings and files
target uip_ethernet_app (ARM-ADS)
  device: -AT32F415CBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: uip_app
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,AT_START_F415_V1
  c include: ..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\..\at32f415_board;..\..\..\..\..\middlewares\3rd_party\uip\port\at32f415_dm9051;..\..\..\..\..\..\AT32F437_DM9051_uip_r2306_rc1.0-\developer\at32f437_board_dm\dm9051_u2510_r_9_1;..\..\..\lwip_dm9051_driver2306v5;..\..\..\..\..\middlewares\3rd_party\uip\inc;..\..\uip_conf_inc;..\..\uip_app_src;..\..\uip_app_src\Eth_app\dhcpc;..\..\uip_app_src\Eth_app\resolv;..\..\uip_app_src\webserver\inc;..\..\uip_arch_src\UNIX
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c at32f415_clock.c at32f415_int.c netconf.c
    ../../../../../middlewares/3rd_party/uip/port/at32f415_dm9051/: ethernetif.c
    ../../uip_arch_src/UNIX/: clock-arch.c
  group bsp
    ../../../../at32f415_board/: at32f415_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f415_crm.c at32f415_usart.c at32f415_gpio.c at32f415_misc.c at32f415_spi.c at32f415_tmr.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f415.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f415.s
  group uip
    ../../../../../middlewares/3rd_party/uip/src/: uip.c uip_arp.c timer.c psock - EditA.c
    ../../uip_app_src/: uip-conf.c app_call.c
    ../../uip_app_src/Eth_app/debug_app/: debug_app.c
    ../../uip_app_src/Eth_app/resolv/: resolv.c
    ../../uip_arch_src/UNIX/: main_unix.c
  group readme
    ../: readme.txt
  group ethernet_app
    ../../uip_app_src/webserver/src/DM/: httpd.c httpd-fs.c httpd-cgi-test1.c http-strings.c
  group new
    ../../../dm9051_u2510_r_9_1/core/: dm9051.c
    ../../../dm9051_u2510_r_9_1/hal/SPI1/: at32f415_spi1.c
    ../src/: main_env.c
    ../../../dm9051_u2510_if/common/: platforminfo_uip_v0.c
