# Keil uVision project ptp_daemon.uvprojx, settings and files
target ptp_daemon (ARM-ADS)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\..\..\libraries\drivers\inc;..\..\..\libraries\cmsis\cm4\core_support;..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\project\at32f403a_407_board;..\..\..\middlewares\3rd_party\lwip_2.1.2\port;..\..\..\middlewares\3rd_party\lwip_2.1.2\port\arch;..\..\..\middlewares\3rd_party\lwip_2.1.2\src\include;..\..\..\middlewares\3rd_party\lwip_2.1.2\src\include\lwip;..\..\..\middlewares\3rd_party\ptpd-2.0.0\src;..\..\dm9051_elwip_app;..\..\dm9051_u2510_if;..\..\dm9051_u2510_r_9_1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c at32_emac.c main.c netconf.c mqtt_client.c mqtt_client_cb.c
    ../../dm9051_elwip_app/: iperf1_tcp.c iperf1_udp.c
  group bsp
    ../../../project/at32f403a_407_board/: at32f403a_407_board.c
  group firmware
    ../../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_spi.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group lwip
    ../../../middlewares/3rd_party/lwip_2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../middlewares/3rd_party/lwip_2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../middlewares/3rd_party/lwip_2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../middlewares/3rd_party/lwip_2.1.2/src/netif/: ethernet.c
    ../../../middlewares/3rd_party/lwip_2.1.2/port/: ethernetif.c sys_arch.c
  group ptpd
    ../../../middlewares/3rd_party/ptpd-2.0.0/src/: arith.c bmc.c protocol.c ptpd.c
    ../../../middlewares/3rd_party/ptpd-2.0.0/src/dep/: msg.c net.c servo.c startup.c sys_time.c timer.c
  group readme
    ../: readme.txt
  group dm9051_edriver
    ../../../libraries/drivers/src/: at32f403a_407_dma.c
    ../../dm9051_u2510_r_9_1/hal/SPI1/: at32f403a_spi1_dma.c
    ../../dm9051_u2510_if/common/nosys/: hex_dump.c
    ../../dm9051_u2510_if/common/port/: plat_lwip.c devif_ptpTrans.c
    ../../dm9051_u2510_if/common/: platform_info_lwip.c
    ../../dm9051_u2510_r_9_1/core/: dm9051.c
    ../../dm9051_u2510_r_9_1/hal/INT/: at32f403a_int7.c
  group dm9051_edriver_extend
    ../../../middlewares/3rd_party/lwip_2.1.2/src/apps/mqtt/: mqtt.c
    ../../dm9051_u2510_r_9_1/dm9051_edriver_extend/: dm9051a_ptp.c
